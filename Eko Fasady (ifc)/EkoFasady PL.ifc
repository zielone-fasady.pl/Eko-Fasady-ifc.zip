Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2025-06-25T18:37:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Alternate UI 21.1.21.45
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 25 18:37:47 2025 * Host: DESKTOP-C1CLBA4 * Database: C:\Users\VLADYS~1\AppData\Local\Temp\f71aecef-0570-438a-9a7d-af175ec7a9ba\b68ec537-e906-443b-b585-3b1963207527\ifc * Database version: 5507 * Database creation date: Wed Jun 25 18:37:46 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 25 18:37:46 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 25 18:37:46 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Constraints - Elevation: 0 mm
Pset_ProductRequirements - Name: Level 1; Category: Levels
Pset_AirSideSystemInformation - Name: Level 1

# IfcBuildingElementProxy: Model Text:600mm Arial (11)
In: Level 1
Type - Identity Data - Type Name: 600mm Arial
Type - Other - Category: Generic Models; Family Name: Model Text
Type - Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 30 mm
Type - Pset_BuildingElementProxyCommon - Reference: 600mm Arial
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 600mm Arial
Pset_ProvisionForVoid - Shape: Undefined; Width: 5 mm; Depth: 5 mm
Constraints - Work Plane: Reference Plane : Plane
Dimensions - Depth: 5 mm
Graphics - Horizontal Align: Left
Identity Data - Subcategory: Generic Models
Materials and Finishes - Material: Napis czarny
Other - Family: Model Text: 600mm Arial; Family and Type: Model Text: 600mm Arial; Type: Model Text: 600mm Arial; Type Id: Model Text: 600mm Arial
Phasing - Phase Created: New Construction
Name (Model Text:600mm Arial:...) | Pset_BuildingElementProxyCommon, sets with these values | Text
509290 | 2 | MODUŁ STANDARDOWY 250x500
509310 | 2 | MODUŁ KATALOGOWY 250x610
509360 | 2 | MODUŁ KATALOGOWY 250x390
509361 | 2 | MODUŁ KATALOGOWY 250x280
509369 | 2 | MODUŁ KATALOGOWY 250x170
509441 | 2 | MODUŁ KATALOGOWY 125x500
509467 | 2 | MODUŁ KATALOGOWY 125x610
509477 | 2 | MODUŁ KATALOGOWY 125x390
509485 | 2 | MODUŁ KATALOGOWY 125x280
509495 | 2 | MODUŁ KATALOGOWY 125x170
509584 |  | PRZYKŁADOWA ŚCIANA | Pset_ProvisionForVoid - Height: 3.76711 mm; Pset_QuantityTakeOff - sets with these values: 2

# IfcCurtainWall: Curtain Wall:Ściana zielona EcoFacade (10)
In: Level 1
Type - Construction - Automatically Embed: no; Curtain Panel: Panel EcoFacade: Panel EcoFacade; Function: Exterior; Join Condition: Not Defined
Type - Horizontal Grid - Adjust for Mullion Size: no; Spacing: 500 mm
Type - Horizontal Mullions - Border 1 Type: Rectangular Mullion: Profil typu Z 30x20x30x3 dolny; Border 2 Type: Rectangular Mullion: Profil typu Z 30x20x30x3; Interior Type: Rectangular Mullion: Profil typu Z 30x20x30x3
Type - Identity Data - Type Name: Ściana zielona EcoFacade
Type - Other - Category: Walls; Family Name: Curtain Wall
Type - Vertical Grid - Adjust for Mullion Size: no; Spacing: 250 mm
Type - Pset_CurtainWallCommon - IsExternal: no; Reference: Ściana zielona EcoFacade
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: Ściana zielona EcoFacade
Pset_CurtainWallCommon - IsExternal: yes
Constraints - Base Constraint: Level: Level 1; Base is Attached: no; Base Offset: 0 mm; Cross-Section: Vertical; Related to Mass: no; Room Bounding: yes; Top is Attached: no; Top Offset: 0 mm
Horizontal Grid - Angle: 0 deg; Offset: 0 mm; Justification: Beginning; Number: 1; sets with these values: 2
Other - Family: Curtain Wall: Ściana zielona EcoFacade; Family and Type: Curtain Wall: Ściana zielona EcoFacade; Type: Curtain Wall: Ściana zielona EcoFacade; Type Id: Curtain Wall: Ściana zielona EcoFacade
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Name (Curtain Wall:Ściana zielona EcoFacade:...) | Unconnected Height (mm) | Area (m2) | Length (mm)
346591 | 500 | 0.125 | 250
476578 | 610 | 0.1525 | 250
476763 | 390 | 0.0975 | 250
476874 | 280 | 0.07 | 250
476951 | 170 | 0.0425 | 250
477021 | 500 | 0.0625 | 125
477027 | 610 | 0.07625 | 125
477033 | 390 | 0.04875 | 125
477039 | 280 | 0.035 | 125
477045 | 170 | 0.02125 | 125

# IfcCurtainWall: Curtain Wall:Ściana zielona EcoFacade - moduł 250x500, Curtain Wall:Ściana zielona EcoFacade - moduł 250x500:486670
In: Level 1
Type - Construction - Automatically Embed: no; Curtain Panel: Panel EcoFacade: Panel EcoFacade; Function: Exterior; Join Condition: Not Defined
Type - Horizontal Grid - Adjust for Mullion Size: no; Layout: Fixed Distance; Spacing: 500 mm
Type - Horizontal Mullions - Border 1 Type: Rectangular Mullion: Profil typu Z 30x20x30x3 dolny; Border 2 Type: Rectangular Mullion: Profil typu Z 30x20x30x3; Interior Type: Rectangular Mullion: Profil typu Z 30x20x30x3
Type - Identity Data - Type Name: Ściana zielona EcoFacade - moduł 250x500
Type - Other - Category: Walls; Family Name: Curtain Wall
Type - Vertical Grid - Adjust for Mullion Size: no; Layout: Fixed Distance; Spacing: 250 mm
Type - Vertical Mullions - Border 1 Type: Rectangular Mullion: Profil typu L 40x60x2 - boczny (1); Border 2 Type: Rectangular Mullion: Profil typu L 40x60x2 - boczny (2)
Type - Pset_CurtainWallCommon - IsExternal: no; Reference: Ściana zielona EcoFacade - moduł 250x500
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: Ściana zielona EcoFacade - moduł 250x500
Pset_CurtainWallCommon - IsExternal: yes
Constraints - Base Constraint: Level: Level 1; Base is Attached: no; Base Offset: 0 mm; Cross-Section: Vertical; Related to Mass: no; Room Bounding: yes; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1500 mm
Dimensions - Area: 6 m2; Length: 4000 mm
Horizontal Grid - Angle: 0 deg; Offset: 0 mm; Justification: Beginning; Number: 2
Other - Family: Curtain Wall: Ściana zielona EcoFacade - moduł 250x500; Family and Type: Curtain Wall: Ściana zielona EcoFacade - moduł 250x500; Type: Curtain Wall: Ściana zielona EcoFacade - moduł 250x500; Type Id: Curtain Wall: Ściana zielona EcoFacade - moduł 250x500
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Vertical Grid - Angle: 0 deg; Offset: 0 mm; Justification: Beginning; Number: 15

# IfcMember: Rectangular Mullion:Profil typu L 40x60x2 - boczny (1) (3)
In: Level 1
Type - PredefinedType: MULLION; Material: Profil aluminiowy
Type - Constraints - Angle: 0 deg; Offset: 0 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Profile: EcoFacade profil L boczny (1): Profil L 40x60x2; Thickness: 60 mm
Type - Dimensions - Width on side 1: 0 mm; Width on side 2: 0 mm
Type - Identity Data - Type Name: Profil typu L 40x60x2 - boczny (1)
Type - Materials and Finishes - Material: Profil aluminiowy
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Type - Pset_MemberCommon - IsExternal: no; Reference: Profil typu L 40x60x2 - boczny (1)
Type - Pset_ProductRequirements - Category: Curtain Wall Mullions
Type - Pset_QuantityTakeOff - Reference: Profil typu L 40x60x2 - boczny (1)
Constraints - Level: Level: Level 1
Dimensions - Area: 0.050196 m2; Length: 500 mm; Volume: 0.000098 m3
Other - Host Id: Curtain Wall: Ściana zielona EcoFacade - moduł 250x500; Family: Rectangular Mullion: Profil typu L 40x60x2 - boczny (1); Family and Type: Rectangular Mullion: Profil typu L 40x60x2 - boczny (1); Type: Rectangular Mullion: Profil typu L 40x60x2 - boczny (1); Type Id: Rectangular Mullion: Profil typu L 40x60x2 - boczny (1)
Phasing - Phase Created: New Construction
Pset_MemberCommon - IsExternal: yes; Span: 500 mm
BaseQuantities - Length: 500 mm; CrossSectionArea: 0.050196 m2; NetVolume: 0.000098 m3
Name (Rectangular Mullion:Profil typu L 40x60x2 - boczny (1):...) | NetSurfaceArea (m2)
506491 | 0.1
506492 | 0.100196
506493 | 0.100196

# IfcMember: Rectangular Mullion:Profil typu L 40x60x2 - boczny (2) (3)
In: Level 1
Type - PredefinedType: MULLION; Material: Profil aluminiowy
Type - Constraints - Angle: 0 deg; Offset: 0 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Profile: EcoFacade profil L boczny (2): Profil L 40x60x2; Thickness: 60 mm
Type - Dimensions - Width on side 1: 0 mm; Width on side 2: 0 mm
Type - Identity Data - Type Name: Profil typu L 40x60x2 - boczny (2)
Type - Materials and Finishes - Material: Profil aluminiowy
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Type - Pset_MemberCommon - IsExternal: no; Reference: Profil typu L 40x60x2 - boczny (2)
Type - Pset_ProductRequirements - Category: Curtain Wall Mullions
Type - Pset_QuantityTakeOff - Reference: Profil typu L 40x60x2 - boczny (2)
Constraints - Level: Level: Level 1
Dimensions - Area: 0.050196 m2; Length: 500 mm; Volume: 0.000098 m3
Other - Host Id: Curtain Wall: Ściana zielona EcoFacade - moduł 250x500; Family: Rectangular Mullion: Profil typu L 40x60x2 - boczny (2); Family and Type: Rectangular Mullion: Profil typu L 40x60x2 - boczny (2); Type: Rectangular Mullion: Profil typu L 40x60x2 - boczny (2); Type Id: Rectangular Mullion: Profil typu L 40x60x2 - boczny (2)
Phasing - Phase Created: New Construction
Pset_MemberCommon - IsExternal: yes; Span: 500 mm
BaseQuantities - Length: 500 mm; CrossSectionArea: 0.050196 m2; NetVolume: 0.000098 m3
Name (Rectangular Mullion:Profil typu L 40x60x2 - boczny (2):...) | NetSurfaceArea (m2)
506511 | 0.100196
506512 | 0.1
506513 | 0.100196

# IfcMember: Rectangular Mullion:Profil typu L 40x60x2 - środkowy (24)
In: Level 1
Type - PredefinedType: MULLION; Material: Profil aluminiowy
Type - Constraints - Angle: 0 deg; Offset: 0 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Profile: EcoFacade profil L środkowy: Profil L 40x60x2; Thickness: 2 mm
Type - Dimensions - Width on side 1: 0 mm; Width on side 2: 0 mm
Type - Identity Data - Type Name: Profil typu L 40x60x2 - środkowy
Type - Materials and Finishes - Material: Profil aluminiowy
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Type - Pset_MemberCommon - IsExternal: no; Reference: Profil typu L 40x60x2 - środkowy
Type - Pset_ProductRequirements - Category: Curtain Wall Mullions
Type - Pset_QuantityTakeOff - Reference: Profil typu L 40x60x2 - środkowy
Constraints - Level: Level: Level 1
Dimensions - Area: 0.050196 m2; Length: 500 mm; Volume: 0.000098 m3
Other - Host Id: Curtain Wall: Ściana zielona EcoFacade - moduł 250x500; Family: Rectangular Mullion: Profil typu L 40x60x2 - środkowy; Family and Type: Rectangular Mullion: Profil typu L 40x60x2 - środkowy; Type: Rectangular Mullion: Profil typu L 40x60x2 - środkowy; Type Id: Rectangular Mullion: Profil typu L 40x60x2 - środkowy
Phasing - Phase Created: New Construction
Pset_MemberCommon - IsExternal: yes; Span: 500 mm
BaseQuantities - Length: 500 mm; CrossSectionArea: 0.050196 m2; NetVolume: 0.000098 m3
Name (Rectangular Mullion:Profil typu L 40x60x2 - środkowy:...) | NetSurfaceArea (m2)
504854 | 0.100196
504855 | 0.1
504856 | 0.100196
506396 | 0.100196
506397 | 0.1
506398 | 0.100196
506402 | 0.100196
506403 | 0.1
506404 | 0.100196
506405 | 0.100196
506406 | 0.1
506407 | 0.100196
506408 | 0.100196
506409 | 0.1
506410 | 0.100196
506411 | 0.100196
506412 | 0.1
506413 | 0.100196
506414 | 0.100196
506415 | 0.1
506416 | 0.100196
506417 | 0.100196
506418 | 0.1
506419 | 0.100196

# IfcMember: Rectangular Mullion:Profil typu Z 30x20x30x3 (58)
In: Level 1
Type - PredefinedType: MULLION; Material: Profil aluminiowy
Type - Constraints - Angle: 0 deg; Offset: 0 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Profile: EcoFacade profil Z środkowy: Profil typu Z 30x20x30x3; Thickness: 0 mm
Type - Dimensions - Width on side 1: 0 mm; Width on side 2: 0 mm
Type - Identity Data - Type Name: Profil typu Z 30x20x30x3
Type - Materials and Finishes - Material: Profil aluminiowy
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Type - Pset_MemberCommon - IsExternal: no; Reference: Profil typu Z 30x20x30x3
Type - Pset_ProductRequirements - Category: Curtain Wall Mullions
Type - Pset_QuantityTakeOff - Reference: Profil typu Z 30x20x30x3
Constraints - Level: Level: Level 1
Other - Family: Rectangular Mullion: Profil typu Z 30x20x30x3; Family and Type: Rectangular Mullion: Profil typu Z 30x20x30x3; Type: Rectangular Mullion: Profil typu Z 30x20x30x3; Type Id: Rectangular Mullion: Profil typu Z 30x20x30x3
Phasing - Phase Created: New Construction
Pset_MemberCommon - IsExternal: yes
Name (Rectangular Mullion:Profil typu Z 30x20x30x3:...) | Area (m2) = CrossSectionArea (m2) | Dimensions, Length (mm) = Span (mm) = BaseQuantities, Length (mm) | Volume (m3) = NetVolume (m3) | Host Id | NetSurfaceArea (m2)
470995 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
476580 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
476765 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
476876 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
476953 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
477023 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
477029 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
477035 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
477041 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
477047 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
486672 | 0.014852 | 190 | 0.00004218 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.029704
487632 | 0.014852 | 190 | 0.00004218 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.029704
487633 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487634 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487635 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487636 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487637 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487638 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487639 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487640 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487641 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487642 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487643 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487644 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487645 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487646 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488162 | 0.014852 | 190 | 0.00004218 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.029704
488163 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488164 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488165 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488166 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488167 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488168 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488169 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488170 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488171 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488172 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488173 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488174 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488175 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488176 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488177 | 0.014852 | 190 | 0.00004218 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.029704
488178 | 0.014852 | 190 | 0.00004218 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.029704
488179 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488180 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488181 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488182 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488183 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488184 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488185 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488186 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488187 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488188 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488189 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488190 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488191 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488192 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
488193 | 0.014852 | 190 | 0.00004218 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.029704

# IfcMember: Rectangular Mullion:Profil typu Z 30x20x30x3 dolny (26)
In: Level 1
Type - PredefinedType: MULLION; Material: Profil aluminiowy
Type - Constraints - Angle: 0 deg; Offset: 0 mm
Type - Construction - Corner Mullion: no; Position: Perpendicular to Face; Thickness: 0 mm; Profile: EcoFacade profil Z dolny: Profil typu Z 30x20x30x3
Type - Dimensions - Width on side 1: 0 mm; Width on side 2: 0 mm
Type - Identity Data - Type Name: Profil typu Z 30x20x30x3 dolny
Type - Materials and Finishes - Material: Profil aluminiowy
Type - Other - Category: Curtain Wall Mullions; Family Name: Rectangular Mullion
Type - Pset_MemberCommon - IsExternal: no; Reference: Profil typu Z 30x20x30x3 dolny
Type - Pset_ProductRequirements - Category: Curtain Wall Mullions
Type - Pset_QuantityTakeOff - Reference: Profil typu Z 30x20x30x3 dolny
Constraints - Level: Level: Level 1
Other - Family: Rectangular Mullion: Profil typu Z 30x20x30x3 dolny; Family and Type: Rectangular Mullion: Profil typu Z 30x20x30x3 dolny; Type: Rectangular Mullion: Profil typu Z 30x20x30x3 dolny; Type Id: Rectangular Mullion: Profil typu Z 30x20x30x3 dolny
Phasing - Phase Created: New Construction
Pset_MemberCommon - IsExternal: yes
Name (Rectangular Mullion:Profil typu Z 30x20x30x3 dolny:...) | Area (m2) = CrossSectionArea (m2) | Dimensions, Length (mm) = Span (mm) = BaseQuantities, Length (mm) | Volume (m3) = NetVolume (m3) | Host Id | NetSurfaceArea (m2)
471179 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
476581 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
476766 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
476877 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
476954 | 0.019472 | 250 | 0.0000555 | Curtain Wall: Ściana zielona EcoFacade | 0.038944
477024 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
477030 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
477036 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
477042 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
477048 | 0.009847 | 125 | 0.00002775 | Curtain Wall: Ściana zielona EcoFacade | 0.019694
486673 | 0.014852 | 190 | 0.00004218 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.029704
487647 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487648 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487649 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487650 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487651 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487652 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487653 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487654 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487655 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487656 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487657 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487658 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487659 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487660 | 0.017932 | 230 | 0.00005106 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.035642
487661 | 0.014852 | 190 | 0.00004218 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 0.029704

# IfcPlate: Panel EcoFacade:Panel EcoFacade (58)
In: Level 1
Type - PredefinedType: CURTAIN_PANEL; Material: Stal nierdzewna AISI 304, Wełna skalna
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Construction Type: nie dotyczy
Type - Identity Data - Description: Moduł systemu zielonej ściany (Eco-Facade); Manufacturer: EcoFacade; OmniClass Number: 23.25.20.14.11.11.17; OmniClass Title: Infill Panels; Type Comments: Zawiera linię nawadniającą (rura 16 mm z emiterami co 125 mm); Type Name: Panel EcoFacade; URL: https://eco-facade.com/
Type - Materials and Finishes - Materiał blachy: Stal nierdzewna AISI 304; Materiał wełny: Wełna skalna
Type - Other - Category: Curtain Panels; Family Name: Panel EcoFacade
Type - Text - Klasyfikacja pożarowa: Niepalny (A1), NRO (polskie i unijne normy)
Type - Pset_ManufacturerTypeInformation - Manufacturer: EcoFacade
Type - Pset_PlateCommon - Reference: Panel EcoFacade; IsExternal: no
Type - Pset_ProductRequirements - Category: Curtain Panels
Type - Pset_QuantityTakeOff - Reference: Panel EcoFacade
Constraints - Level: Level: Level 1
Other - Family: Panel EcoFacade: Panel EcoFacade; Family and Type: Panel EcoFacade: Panel EcoFacade; Moduł katalogowy: yes; Type: Panel EcoFacade: Panel EcoFacade; Type Id: Panel EcoFacade: Panel EcoFacade
Phasing - Phase Created: New Construction
Pset_PlateCommon - IsExternal: yes
Name (Panel EcoFacade:Panel EcoFacade:...) | Area (m2) | Height (mm) = Wysokość (mm) | Szerokość (mm) = Width (mm) | Volume (m3) | Host Id | Ilość koszy | add1_wyświetlanie koszy | add2_wyświetlanie koszy | add3_przybliżona masa modułu (kg)
346592 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade | 4 | no | yes | 6
476579 | 0.1525 | 610 | 250 | 0.00404125 | Curtain Wall: Ściana zielona EcoFacade | 5 | no | yes | 7
476764 | 0.0975 | 390 | 250 | 0.00258375 | Curtain Wall: Ściana zielona EcoFacade | 3 | no | yes | 5
476875 | 0.07 | 280 | 250 | 0.001855 | Curtain Wall: Ściana zielona EcoFacade | 2 | no | yes | 3
476952 | 0.0425 | 170 | 250 | 0.00112625 | Curtain Wall: Ściana zielona EcoFacade | 2 | yes | no | 2
477022 | 0.0625 | 500 | 125 | 0.00165625 | Curtain Wall: Ściana zielona EcoFacade | 4 | no | yes | 3
477028 | 0.07625 | 610 | 125 | 0.00202062 | Curtain Wall: Ściana zielona EcoFacade | 5 | no | yes | 4
477034 | 0.04875 | 390 | 125 | 0.00129187 | Curtain Wall: Ściana zielona EcoFacade | 3 | no | yes | 2
477040 | 0.035 | 280 | 125 | 0.0009275 | Curtain Wall: Ściana zielona EcoFacade | 2 | no | yes | 2
477046 | 0.02125 | 170 | 125 | 0.000563125 | Curtain Wall: Ściana zielona EcoFacade | 2 | yes | no | 1
486671 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487590 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487592 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487594 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487596 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487598 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487600 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487602 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487604 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487606 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487608 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487610 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487612 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487614 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487616 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
487618 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488092 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488093 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488094 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488095 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488096 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488097 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488098 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488099 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488100 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488101 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488102 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488103 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488104 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488105 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488106 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488107 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488109 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488110 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488111 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488112 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488113 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488114 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488115 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488116 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488117 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488118 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488119 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488120 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488121 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488122 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488123 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
488124 | 0.125 | 500 | 250 | 0.0033125 | Curtain Wall: Ściana zielona EcoFacade - moduł 250x500 | 4 | no | yes | 6
